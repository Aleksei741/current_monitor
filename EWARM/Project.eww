<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\usb_com_port_stm32F401RCT6.ewp</path>
  </project>
  <batchBuild />
</workspace>
